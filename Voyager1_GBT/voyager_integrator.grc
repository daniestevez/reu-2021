options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: voyager_integrator
    output_language: python
    title: Voyager-1 spectrum integrator from GUPPI file
  states: {}

blocks:
- name: chan_centre
  id: variable
  parameters:
    value: '8420507812.5'
  states: {}
- name: db_scale
  id: variable
  parameters:
    value: '-85'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: 2**16
  states: {}
- name: integrate
  id: variable
  parameters:
    value: int(samp_rate/fft_size*integrate_seconds)
  states: {}
- name: integrate_seconds
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.9296875e6
  states: {}
- name: voyager_freq
  id: variable
  parameters:
    value: 8420.2164537e6
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/voyager/blc3_guppi_57386_VOYAGER1_0004.0000_only_vgr1_chan.ci8
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: integrate
    type: float
    vlen: fft_size
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: integrate
    type: float
    vlen: fft_size
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: db_scale
    n: '10'
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: db_scale
    n: '10'
    vlen: fft_size
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '100'
    type: float
    vlen: fft_size
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: '100'
    type: float
    vlen: fft_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class GuppiFile():
          """A class to read data from a file in GUPPI format"""
          # we only support 8bit files
          def __init__(self, filename, header_len, blocsize, npol, nchan, centre_freq, chan_bw):
              self.f = open(filename, 'rb')
              self.header_len = header_len
              self.blocsize = blocsize
              self.npol = npol
              self.nchan = nchan
              self.ntime = blocsize // (2 * npol * nchan)
              self.centre_freq = centre_freq
              self.chan_bw = chan_bw
              self.chan_len = 2 * npol * self.ntime
          
          def get_channel(self, freq):
              """Return the channel number to which the frequency freq (in Hz) belongs"""
              return self.nchan - 1 - int((freq - self.centre_freq + self.chan_bw * self.nchan // 2) / self.chan_bw)
          
          def read_block_from_channel(self, block, channel):
              """Read and return a given block from a channel"""
              self.f.seek((block + 1) * self.header_len + (block * self.nchan  + channel) * self.chan_len)
              b = np.fromfile(self.f, dtype = np.int8, count = self.chan_len)
              if len(b) == 0:
                  return None
              b = b[::2] - 1j * b[1::2] # Convert to complex and invert frequency
              return b.reshape((self.npol, self.ntime), order = 'F')
          
          def centre_frequency(self, channel):
              """Return the centre frequency for a given channel"""
              return self.centre_freq + (self.nchan // 2 - channel) * self.chan_bw

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, frequency=0.0, repeat=True):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='GUPPI File Source',   # will show up in GRC
                  in_sig=[],
                  out_sig=[np.complex64, np.complex64]
              )
              npols = 2
              self.repeat = repeat
              self.guppi = GuppiFile('blc3_guppi_57386_VOYAGER1_0004.0000.raw',
                        header_len = 0x1900, blocsize = 132251648,
                        npol = npols, nchan = 64,
                        centre_freq = 8493.75e6,
                        chan_bw = 2.9296875e6)
              self.chan = self.guppi.get_channel(frequency)
              print('centre freq =', self.guppi.centre_frequency(self.chan))
              self.currblock = -1
              self.block = np.empty((npols, 0), dtype='complex64')

          def work(self, input_items, output_items):
              if self.block.shape[1] < len(output_items[0]):
                  self.currblock += 1
                  newblock = self.guppi.read_block_from_channel(
                      self.currblock, self.chan)
                  if newblock is None and self.repeat:
                      self.currblock = 0
                      newblock = self.guppi.read_block_from_channel(
                          self.currblock, self.chan)
                      assert newblock is not None
                  if newblock is not None:
                      self.block = np.concatenate((self.block, newblock.astype('complex64')),
                                                  axis=1)
              L = min(len(output_items[0]), self.block.shape[1])
              if L == 0:
                  return -1
                                           
              for j in range(self.block.shape[0]):
                  output_items[j][:L] = self.block[j, :L]
              self.block = self.block[:, L:]

              return L
    frequency: voyager_freq
    repeat: 'True'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    nconnections: '2'
    vlen: fft_size
    x_start: '0'
    x_step: '1.0'
    ymax: '20'
    ymin: '-10'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: lhcp
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: rhcp
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: lhcp
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: rhcp
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_integrate_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_throttle_0_0, '0']
- [blocks_nlog10_ff_0, '0', virtual_sink_0, '0']
- [blocks_nlog10_ff_0_0, '0', virtual_sink_0_0, '0']
- [blocks_repeat_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_repeat_0_0, '0', qtgui_vector_sink_f_0, '1']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [epy_block_0, '0', blocks_throttle_0, '0']
- [epy_block_0, '1', blocks_throttle_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [virtual_source_0, '0', blocks_repeat_0, '0']
- [virtual_source_0_0, '0', blocks_repeat_0_0, '0']

metadata:
  file_format: 1
