options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: voyager_spectrum
    output_language: python
    title: Voyager-1 spectrum from GUPPI file
  states: {}

blocks:
- name: chan_centre
  id: variable
  parameters:
    value: '8420507812.5'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '35'
  states: {}
- name: decimation2
  id: variable
  parameters:
    value: '500'
  states: {}
- name: decimation2sb
  id: variable
  parameters:
    value: '50'
  states: {}
- name: nfft
  id: variable
  parameters:
    value: '256'
  states: {}
- name: nfftsb
  id: variable
  parameters:
    value: '512'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.9296875e6
  states: {}
- name: voyager_freq
  id: variable
  parameters:
    value: 8420.2164537e6
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    vector_output: 'False'
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfftsb
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: carrier_waterfall.f32
    type: float
    vlen: nfft
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: sideband_waterfall.f32
    type: float
    vlen: nfftsb
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: blc3_guppi_57386_VOYAGER1_0004.0000_only_vgr1_chan.ci8
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/voyager/blc3_guppi_57386_VOYAGER1_0004.0000_only_vgr1_chan.ci8
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfftsb
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class GuppiFile():
          """A class to read data from a file in GUPPI format"""
          # we only support 8bit files
          def __init__(self, filename, header_len, blocsize, npol, nchan, centre_freq, chan_bw):
              self.f = open(filename, 'rb')
              self.header_len = header_len
              self.blocsize = blocsize
              self.npol = npol
              self.nchan = nchan
              self.ntime = blocsize // (2 * npol * nchan)
              self.centre_freq = centre_freq
              self.chan_bw = chan_bw
              self.chan_len = 2 * npol * self.ntime
          
          def get_channel(self, freq):
              """Return the channel number to which the frequency freq (in Hz) belongs"""
              return self.nchan - 1 - int((freq - self.centre_freq + self.chan_bw * self.nchan // 2) / self.chan_bw)
          
          def read_block_from_channel(self, block, channel):
              """Read and return a given block from a channel"""
              self.f.seek((block + 1) * self.header_len + (block * self.nchan  + channel) * self.chan_len)
              b = np.fromfile(self.f, dtype = np.int8, count = self.chan_len)
              if len(b) == 0:
                  return None
              b = b[::2] - 1j * b[1::2] # Convert to complex and invert frequency
              return b.reshape((self.npol, self.ntime), order = 'F')
          
          def centre_frequency(self, channel):
              """Return the centre frequency for a given channel"""
              return self.centre_freq + (self.nchan // 2 - channel) * self.chan_bw

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, frequency=0.0, repeat=True):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='GUPPI File Source',   # will show up in GRC
                  in_sig=[],
                  out_sig=[np.complex64, np.complex64]
              )
              npols = 2
              self.repeat = repeat
              self.guppi = GuppiFile('blc3_guppi_57386_VOYAGER1_0004.0000.raw',
                        header_len = 0x1900, blocsize = 132251648,
                        npol = npols, nchan = 64,
                        centre_freq = 8493.75e6,
                        chan_bw = 2.9296875e6)
              self.chan = self.guppi.get_channel(frequency)
              print('centre freq =', self.guppi.centre_frequency(self.chan))
              self.currblock = -1
              self.block = np.empty((npols, 0), dtype='complex64')

          def work(self, input_items, output_items):
              if self.block.shape[1] < len(output_items[0]):
                  self.currblock += 1
                  newblock = self.guppi.read_block_from_channel(
                      self.currblock, self.chan)
                  if newblock is None and self.repeat:
                      self.currblock = 0
                      newblock = self.guppi.read_block_from_channel(
                          self.currblock, self.chan)
                      assert newblock is not None
                  if newblock is not None:
                      self.block = np.concatenate((self.block, newblock.astype('complex64')),
                                                  axis=1)
              L = min(len(output_items[0]), self.block.shape[1])
              if L == 0:
                  return -1
                                           
              for j in range(self.block.shape[0]):
                  output_items[j][:L] = self.block[j, :L]
              self.block = self.block[:, L:]

              return L
    frequency: voyager_freq
    repeat: 'False'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: nfftsb
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfftsb)
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: voyager_freq - chan_centre
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 35e3, 5e3)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: voyager_freq - chan_centre
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 35e3, 5e3)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 22.5e3
    decim: decimation2sb
    samp_rate: samp_rate/decimation
    taps: firdes.low_pass(1, samp_rate/decimation, 700, 50)
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50'
    decim: decimation2
    gain: '1'
    samp_rate: samp_rate/decimation
    type: fir_filter_ccf
    width: '10'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,0,1,2
    label1: LHCP polarization
    label2: RHCP polarization
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation/decimation2
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0,1,1
    name: Carrier (zoomed in)
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation/decimation2sb
    fc: '0'
    fftsize: '4096'
    gui_hint: 1,1,1,1
    name: Right data sideband (zoomed in)
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: voyager
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: voyager
  states: {}

connections:
- [blocks_complex_to_interleaved_char_0, '0', blocks_file_sink_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_throttle_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_interleaved_char_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [epy_block_0, '0', blocks_throttle_0, '0']
- [epy_block_0, '1', blocks_throttle_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', virtual_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_0, '1']
- [freq_xlating_fir_filter_xxx_1, '0', blocks_stream_to_vector_0_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', qtgui_freq_sink_x_0_0_0, '0']
- [low_pass_filter_0, '0', blocks_stream_to_vector_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [virtual_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
