options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: tianwen1_480k
    output_language: python
    run_options: run
    title: Tianwen-1 telemetry decoder
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/decim/baudrate
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: 3*math.pi
    min_freq: '-3*math.pi'
    w: 2*math.pi*pll_bw/samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_off
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: baudrate
  id: parameter
  parameters:
    type: intx
    value: '16384'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: tianwen1_frames.u8
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/tianwen-1-reu/Tianwen-1_2021-02-13T21 42 03.868296_x.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/tianwen-1-reu/Tianwen-1_2021-02-13T21 42 03.868296_y.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.001'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.01'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Auto-polarization
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Auto-polarization"""

          def __init__(self, fft_size=1024, fft_avg=1,
                           iir_weight = 1e-2): # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Auto-polarization',   # will show up in GRC
                  in_sig=[np.complex64]*2,
                  out_sig=[np.complex64]*2
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.fft_size = fft_size
              self.fft_avg = fft_avg
              self.set_output_multiple(fft_size * fft_avg)
              self.iir_weight = iir_weight
              self.noise_ampl = np.ones(2)
              self.sig_ampl = np.ones(2)
              self.phase = 0

          def work(self, input_items, output_items):
              x = np.array([inp.reshape((-1, self.fft_avg, self.fft_size))
                                for inp in input_items])
              # axes for x are:
              # (channel: 2, block, fft_num: fft_avg, fft_bin: fft_size)

              fx = np.fft.fft(x)
              fx_sq_avg = np.average(np.abs(fx)**2, axis = 2)
              noise_ampl = np.sqrt(np.median(fx_sq_avg, axis = 2))

              fx_sq_avg_ch_max = np.max(fx_sq_avg/noise_ampl[...,np.newaxis]**2, axis = 0)
              peak_idx = np.argmax(fx_sq_avg_ch_max, axis = 1)

              f_cross = np.average(fx[0] * np.conjugate(fx[1]), axis = 1)
              phase = np.angle(f_cross[np.arange(f_cross.shape[0]),
                                           peak_idx])
              sig_ampl = fx_sq_avg[:,np.arange(fx_sq_avg.shape[1]),peak_idx] #- noise_ampl
              sig_ampl = np.sqrt(np.clip(sig_ampl, 0, np.inf))

              # update IIR filters
              for j in range(x.shape[1]):
                  noise_ampl[:,j] = (1-self.iir_weight)*self.noise_ampl \
                    + self.iir_weight*noise_ampl[:,j]
                  self.noise_ampl = noise_ampl[:,j]
                  sig_ampl[:,j] = (1-self.iir_weight)*self.sig_ampl \
                    + self.iir_weight*sig_ampl[:,j]
                  self.sig_ampl = sig_ampl[:,j]
                  phase_diff = phase[j] - self.phase
                  phase_diff = (phase_diff + np.pi) % (2*np.pi) - np.pi
                  phase[j] = self.phase + self.iir_weight*phase_diff
                  self.phase = (phase[j] + np.pi) % (2*np.pi) - np.pi

              tau = np.log10(sig_ampl[0]/noise_ampl[0]+1e-6) \
                - np.log10(sig_ampl[1]/noise_ampl[1]+1e-6)
              tau = 20*tau/6*0.5 + 0.5
              tau = np.clip(tau, 0, 1)
              # note tau = 1 if sig[0] is 6dB stronger than sig[1] and
              # tau = 0 if sig[0] is 6dB weaker than sig[1]
              a_phase = (tau - 1) * phase
              b_phase = tau * phase
              # note -a_phase + b_phase = phase
              
              alpha = (np.exp(1j*a_phase) * sig_ampl[0] / noise_ampl[0])[:,np.newaxis]
              beta = (np.exp(1j*b_phase) * sig_ampl[1] / noise_ampl[1])[:,np.newaxis]

              y = x.reshape((x.shape[0], x.shape[1], self.fft_avg * self.fft_size))
              y = y / noise_ampl[...,np.newaxis] * np.sqrt(self.fft_size)
              output_items[0][:] = (alpha * y[0] + beta * y[1]).ravel()
              output_items[1][:] = (np.conjugate(beta) * y[0] - np.conjugate(alpha) * y[1]).ravel()
              return len(output_items[0])
    fft_avg: int(0.1*samp_rate/2048)
    fft_size: '2048'
    iir_weight: '0.01'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1/7]*7'
    type: ccc
  states: {}
- name: freq_off
  id: parameter
  parameters:
    type: eng_float
    value: 5.63e3
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '65536'
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, samp_rate/(2*decim)-250, 500)
    type: fcf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pll_bw
  id: parameter
  parameters:
    type: eng_float
    value: '20'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    legend: 'False'
    name: Constellation
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label: PSD
    label1: Signal polarization
    label2: Orthogonal polarization
    name: Auto-polarization output
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-35'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    label: PDS
    label1: In-phase
    label2: Quadrature
    name: PLL output
    nconnections: '2'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-10'
    ymin: '-60'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate/decim
    fc: '0'
    fftsize: '4096'
    label: PDS
    label1: Unfiltered
    label2: Filtered
    legend: 'False'
    name: Data subcarrier
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-35'
    ymin: '-55'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_2
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label: PSD
    label1: X polarization
    label2: Y polarization
    name: Antenna signals
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '20'
    ymin: '-20'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_3
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label: PSD
    legend: 'False'
    name: Mixer output
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-10'
    ymin: '-60'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: I
    label2: Q
    marker1: '0'
    marker2: '0'
    name: Symbols vs time
    size: '10000'
    srate: baudrate
    style1: '0'
    style2: '0'
    type: complex
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: satellites_ccsds_concatenated_deframer_0
  id: satellites_ccsds_concatenated_deframer
  parameters:
    convolutional: '"CCSDS"'
    frame_size: '220'
    precoding: None
    rs_basis: '"conventional"'
    rs_interleaving: '1'
    scrambler: '"CCSDS"'
    threshold: '4'
  states: {}
- name: satellites_ccsds_concatenated_deframer_0_0
  id: satellites_ccsds_concatenated_deframer
  parameters:
    convolutional: '"CCSDS"'
    frame_size: '220'
    precoding: None
    rs_basis: '"conventional"'
    rs_interleaving: '1'
    scrambler: '"CCSDS"'
    threshold: '4'
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}
- name: satellites_rms_agc_0_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_float_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_complex_to_float_0, '0', blocks_null_sink_1, '0']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_complex_to_float_0, '1', freq_xlating_fir_filter_xxx_1, '0']
- [blocks_complex_to_float_0, '1', qtgui_freq_sink_x_0_0, '1']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_real_0, '0', satellites_ccsds_concatenated_deframer_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', epy_block_0, '1']
- [blocks_interleaved_short_to_complex_0_0, '0', qtgui_freq_sink_x_0_2, '1']
- [blocks_multiply_conjugate_cc_0, '0', analog_pll_carriertracking_cc_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_freq_sink_x_0_3, '0']
- [blocks_multiply_const_vxx_0, '0', satellites_ccsds_concatenated_deframer_0_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_null_sink_0, '0']
- [blocks_throttle_0, '0', epy_block_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0_2, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, '0', satellites_rms_agc_0, '0']
- [epy_block_0, '1', blocks_null_sink_2, '0']
- [epy_block_0, '1', qtgui_freq_sink_x_0, '1']
- [fir_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_1, '1']
- [freq_xlating_fir_filter_xxx_1, '0', satellites_rms_agc_0_0, '0']
- [satellites_ccsds_concatenated_deframer_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_ccsds_concatenated_deframer_0, out, satellites_hexdump_sink_0, in]
- [satellites_ccsds_concatenated_deframer_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_ccsds_concatenated_deframer_0_0, out, satellites_hexdump_sink_0, in]
- [satellites_rms_agc_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [satellites_rms_agc_0_0, '0', fir_filter_xxx_0, '0']
- [satellites_rms_agc_0_0, '0', qtgui_freq_sink_x_0_1, '0']

metadata:
  file_format: 1
