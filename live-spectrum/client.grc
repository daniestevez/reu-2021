options:
  parameters:
    generate_options: qt_gui
    id: client
    output_language: python
    title: View client flowgraph
  states: {}

blocks:
- name: fc
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 512e6
  states: {}
- name: nfft
  id: variable
  parameters:
    value: 2**13
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40.96e6
  states: {}
- name: tune
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '0'
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: 4*nfft
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '4'
    type: float
    vlen: nfft
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    nconnections: '4'
    vlen: nfft
    x_axis_label: '"Frequency"'
    x_start: '-samp_rate/2'
    x_step: samp_rate/nfft
    x_units: '"Hz"'
    y_axis_label: '"PSD"'
    y_units: '"dB"'
  states: {}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: gnuradio1
    callback: set_fc
    port: '8080'
    variable: fc
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://gnuradio1:5555
    timeout: '100'
    type: float
    vlen: 4*nfft
  states: {}

connections:
- [blocks_nlog10_ff_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_vector_to_streams_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_vector_to_streams_0, '1', qtgui_vector_sink_f_0, '1']
- [blocks_vector_to_streams_0, '2', qtgui_vector_sink_f_0, '2']
- [blocks_vector_to_streams_0, '3', qtgui_vector_sink_f_0, '3']
- [zeromq_sub_source_0, '0', blocks_nlog10_ff_0, '0']

metadata:
  file_format: 1
