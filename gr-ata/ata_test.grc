options:
  parameters:
    generate_options: no_gui
    id: ata_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: ata_control_0
  id: ata_control
  parameters:
    mode: online
    username: ''
  states: {}
- name: ata_ifswitch_0
  id: ata_ifswitch
  parameters:
    ant1: 3l
    ant2: 2j
    ant3: none
  states: {}
- name: ata_trackscan_0
  id: ata_trackscan
  parameters:
    ant_list: 3l, 2j
    az: azimuth
    cfreq: '1575.0'
    coord_type: azel
    dec: '67.0'
    el: elevation
    ra: '14.0'
    src: casa
  states: {}
- name: azimuth
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: elevation
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}

connections:
- [ata_trackscan_0, command, ata_control_0, command]

metadata:
  file_format: 1
