options:
  parameters:
    generate_options: qt_gui
    id: client_serverside_integrator
    output_language: python
    title: ZMQ client (with server-side integrator)
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: int(integration_time*samp_rate/nfft)
  states: {}
- name: gain0
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '1.0'
  states: {}
- name: gain1
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '1.0'
  states: {}
- name: integration_time
  id: variable
  parameters:
    value: '1'
  states: {}
- name: nfft
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3.84e6
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[gain0]*nfft'
    type: float
    vlen: nfft
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[gain1]*nfft'
    type: float
    vlen: nfft
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    nconnections: '2'
    vlen: nfft
    x_axis_label: '"Frequency (MHz)"'
    x_start: 1420.405-samp_rate*1e-6/2
    x_step: samp_rate*1e-6/nfft
    y_axis_label: '"Power spectral density"'
    ymax: '5'
    ymin: '0'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://gnuradio1:5555
    timeout: '100'
    type: float
    vlen: nfft
  states: {}
- name: zeromq_sub_source_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://gnuradio1:5556
    timeout: '100'
    type: float
    vlen: nfft
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_vector_sink_f_0, '1']
- [zeromq_sub_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [zeromq_sub_source_0_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
