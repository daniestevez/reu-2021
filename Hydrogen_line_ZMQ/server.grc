options:
  parameters:
    generate_options: no_gui
    id: server
    output_language: python
    run_options: run
    title: ZMQ server
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: 512e6
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_char_0_0
  id: blocks_complex_to_interleaved_char
  parameters:
    vector_output: 'False'
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 127*dgain
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: 127*dgain
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: dgain
  id: parameter
  parameters:
    type: eng_float
    value: '20'
  states: {}
- name: gaindB
  id: parameter
  parameters:
    label: rx gain in decibels
    short_id: g
    type: eng_float
    value: '45'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sampling rate [Hz]
    short_id: b
    type: eng_float
    value: 3.84e6
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      self.uhd_usrp_source.set_time_next_pps(uhd.time_spec(int(time.time())+1))
      self.uhd_usrp_source.set_lo_export_enabled(True, "lo1", 0)
      self.uhd_usrp_source.set_rx_lo_dist(True, "LO_OUT_0")
      self.uhd_usrp_source.set_rx_lo_dist(True, "LO_OUT_1")
      self.uhd_usrp_source.set_lo_source("external", "lo1", 0)
      self.uhd_usrp_source.set_lo_source("external", "lo1", 1)
      self.uhd_usrp_source.set_lo_source("external", "lo1", 2)
      self.uhd_usrp_source.set_lo_source("external", "lo1", 3)
      time.sleep(1)
    priority: ''
    section: main_after_init
  states: {}
- name: uhd_usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    ant2: RX2
    ant3: RX2
    center_freq0: fc
    center_freq1: fc
    center_freq2: fc
    center_freq3: fc
    clock_source0: external
    clock_source1: external
    dc_offs_enb0: 'False'
    dc_offs_enb1: 'False'
    dc_offs_enb2: 'False'
    dc_offs_enb3: 'False'
    dev_addr: '"addr0=10.11.1.20,addr1=10.11.1.22"'
    dev_args: '""'
    gain0: gaindB
    gain1: gaindB
    gain2: gaindB
    gain3: gaindB
    iq_imbal_enb0: 'False'
    iq_imbal_enb1: 'False'
    iq_imbal_enb2: 'False'
    iq_imbal_enb3: 'False'
    nchan: '4'
    norm_gain0: 'False'
    norm_gain1: 'False'
    norm_gain2: 'False'
    norm_gain3: 'False'
    num_mboards: '2'
    otw: sc16
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:5555
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:5556
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_complex_to_interleaved_char_0, '0', zeromq_pub_sink_0, '0']
- [blocks_complex_to_interleaved_char_0_0, '0', zeromq_pub_sink_0_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_interleaved_char_0, '0']
- [blocks_multiply_const_xx_0_0, '0', blocks_complex_to_interleaved_char_0_0, '0']
- [uhd_usrp_source, '0', blocks_multiply_const_xx_0, '0']
- [uhd_usrp_source, '1', blocks_null_sink_0, '0']
- [uhd_usrp_source, '2', blocks_multiply_const_xx_0_0, '0']
- [uhd_usrp_source, '3', blocks_null_sink_0_0, '0']

metadata:
  file_format: 1
