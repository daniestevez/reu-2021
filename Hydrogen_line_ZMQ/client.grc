options:
  parameters:
    generate_options: qt_gui
    id: client
    output_language: python
    title: ZMQ client
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 3.84e6
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://gnuradio1:5555
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_interleaved_char_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_sub_source_0, '0', blocks_interleaved_char_to_complex_0, '0']

metadata:
  file_format: 1
