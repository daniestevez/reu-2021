options:
  parameters:
    generate_options: no_gui
    id: server_integrator
    output_language: python
    run_options: run
    title: ZMQ server (with integrator)
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: int(integration_time*samp_rate/nfft)
  states: {}
- name: fc
  id: variable
  parameters:
    value: 512e6
  states: {}
- name: integration_time
  id: variable
  parameters:
    value: '1'
  states: {}
- name: nfft
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: decimation
    type: float
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: decimation
    type: float
    vlen: nfft
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1e-2]*nfft'
    type: float
    vlen: nfft
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1e-2]*nfft'
    type: float
    vlen: nfft
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '10'
    type: float
    vlen: nfft
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: '10'
    type: float
    vlen: nfft
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: dgain
  id: parameter
  parameters:
    type: eng_float
    value: '20'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {}
- name: gaindB
  id: parameter
  parameters:
    label: rx gain in decibels
    short_id: g
    type: eng_float
    value: '45'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sampling rate [Hz]
    short_id: b
    type: eng_float
    value: 3.84e6
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      self.uhd_usrp_source.set_time_next_pps(uhd.time_spec(int(time.time())+1))
      self.uhd_usrp_source.set_lo_export_enabled(True, "lo1", 0)
      self.uhd_usrp_source.set_rx_lo_dist(True, "LO_OUT_0")
      self.uhd_usrp_source.set_rx_lo_dist(True, "LO_OUT_1")
      self.uhd_usrp_source.set_lo_source("external", "lo1", 0)
      self.uhd_usrp_source.set_lo_source("external", "lo1", 1)
      self.uhd_usrp_source.set_lo_source("external", "lo1", 2)
      self.uhd_usrp_source.set_lo_source("external", "lo1", 3)
      time.sleep(1)
    priority: ''
    section: main_after_init
  states: {}
- name: uhd_usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    ant2: RX2
    ant3: RX2
    center_freq0: fc
    center_freq1: fc
    center_freq2: fc
    center_freq3: fc
    clock_source0: external
    clock_source1: external
    dc_offs_enb0: 'False'
    dc_offs_enb1: 'False'
    dc_offs_enb2: 'False'
    dc_offs_enb3: 'False'
    dev_addr: '"addr0=10.11.1.20,addr1=10.11.1.22"'
    dev_args: '""'
    gain0: gaindB
    gain1: gaindB
    gain2: gaindB
    gain3: gaindB
    iq_imbal_enb0: 'False'
    iq_imbal_enb1: 'False'
    iq_imbal_enb2: 'False'
    iq_imbal_enb3: 'False'
    nchan: '4'
    norm_gain0: 'False'
    norm_gain1: 'False'
    norm_gain2: 'False'
    norm_gain3: 'False'
    num_mboards: '2'
    otw: sc16
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:5555
    timeout: '100'
    type: float
    vlen: nfft
  states: {}
- name: zeromq_pub_sink_0_1
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:5556
    timeout: '100'
    type: float
    vlen: nfft
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_repeat_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_repeat_0_0, '0']
- [blocks_repeat_0, '0', zeromq_pub_sink_0, '0']
- [blocks_repeat_0_0, '0', zeromq_pub_sink_0_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [uhd_usrp_source, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source, '1', blocks_null_sink_0, '0']
- [uhd_usrp_source, '2', blocks_stream_to_vector_0_0, '0']
- [uhd_usrp_source, '3', blocks_null_sink_0_0, '0']

metadata:
  file_format: 1
